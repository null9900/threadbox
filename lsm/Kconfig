## lsm/Kconfig
```kconfig
config SECURITY_FUNCSANDBOX
	bool "funcsandbox support"
	depends on SECURITY
	help 
funcsandbox help
```
